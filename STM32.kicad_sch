File: STM32.kicad_sch (KiCad schematic)
At the start: 32 parts

Commit message: Stm32
Parts:
- gave numbers to parts that had none: 32
